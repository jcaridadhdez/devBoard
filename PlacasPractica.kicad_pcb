# Repository jcaridadhdez/devBoard

File README.md:

# devBoard
LowPower mutipurpose board using KiCAD

:)

## KiCad design PlacasPractica.kicad_pcb

Parts:
4k1, 4k2: R; R_0805_HandSoldering
ADC1, ADC2: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
C1, C2, C3, C4: 10uF; C_0805_HandSoldering
C5, C10: 100nF; C_0805_HandSoldering
C6, C7: 6.8pF; C_0805_HandSoldering
C8: 1uf; C_0805_HandSoldering
C9: 100nf; C_0805_HandSoldering
C11: 100nF; CP_Elec_6.3x5.8
C12, C13: 4.7uF; C_0805_HandSoldering
C14: 4,7uF; C_0805_HandSoldering
C15, C16, C17: 47uF; CP_Elec_6.3x5.8
C18: 0.1uF; C_0805_HandSoldering
D1, D7: LED; LED_1206_HandSoldering
D2, D3: 5V1; D_SOD-323_HandSoldering
D4, D5, D6: D_Schottky_Small; D_SOD-323_HandSoldering
DIGITAL1, DIGITAL2: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
I2C1: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
J1: USB_OTG; USB_Micro-B_Wuerth-629105150521_CircularHoles
J2, J3: Conn_01x10; Pin_Header_Straight_1x10_Pitch2.54mm
J4: CONN_02X05; Pin_Header_Straight_2x05_Pitch1.00mm
JP1: Jumper; SOLDER-JUMPER_1-WAY
JP2: JxBEE_TXD; SOLDER-JUMPER_2-WAY
JP3: J_xBEE_RXD; SOLDER-JUMPER_2-WAY
JP4: Jumper_NC_Dual; SOLDER-JUMPER_2-WAY
JP5: J_vddcD21_vddcL21; SOLDER-JUMPER_2-WAY
JP6: Jumper_NC_Small; SOLDER-JUMPER_1-WAY
JP7: J_Vsensor_Vcc; SOLDER-JUMPER_2-WAY
JP8: J_Vcom_Vcc; SOLDER-JUMPER_2-WAY
L1: L; Inductor_Taiyo-Yuden_NR-60xx_HandSoldering
ONEWIRE1: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
R1, R3, R4, R5, R7, R9: 330; R_0805_HandSoldering
R2, R10, R11: R; R_0805_HandSoldering
R6, R8: 10k; R_0805_HandSoldering
SW1: SW_Push; SW_SPST_B3U-1000P
U1: SAMD20J18A-AU; TQFP-64_10x10mm_Pitch0.5mm
U2: XBEE
U3: MB85RC64VPNF-G-JNERE1; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4, U5, U6: XC6220B331MR-G; IC-SOT25
U7: 24AA02; SOT-23-5
U8: ATSHA204A; SOIC-8_3.9x4.9mm_Pitch1.27mm
UART1: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
Y1: 48MHz; Crystal_SMD_0603-2pin_6.0x3.5mm_HandSoldering

Connections:
+5V: D4.2 (A), D5.2 (A), D6.2 (A), J1.1 (VBUS)
/3V3: 4k1.1, 4k2.1, C1.2, C2.2, C3.2, C4.2, C8.1, C9.1, C11.1, C15.1, C18.1, J2.2, J3.9, J4.1, L1.1, R6.1, R8.1, U1.21 (VDDIO), U1.34 (VDDIO), U1.48 (VDDIO), U1.56 (VDDIN), U3.8 (VDD), U4.5 (VOUT), U7.4, U8.8
/3V3_COM: C17.1, DIGITAL1.3, DIGITAL2.3, U2.1 (VCC), U6.5 (VOUT), UART1.3; also elsewhere on the board
/3V3_SENS: ADC1.3, ADC2.3, C16.1, I2C1.3, ONEWIRE1.3, R1.2, U5.5 (VOUT); also elsewhere on the board
/A0: ADC1.2, U1.3 (VOUT/Y0/AIN0/PA02)
/A1: ADC2.2, U1.15 (TC1WO0/SERCOM0P2/Y4/AIN2/AIN6/PA06)
/A2: J2.3, U1.14 (TC0W01/SERCOM0P1/Y3/AIN1/AIN5/PA05)
/A3: J2.4, U1.13 (TC0WO0/SERCOM0P0/Y2/AIN0/AIN4/VREFB/PA04)
/A4: J2.5, U1.12 (PB09/AIN3/Y15/SERCOM4P1/TC4WO1)
/A5: J2.6, U1.11 (PB08/AIN2/Y14/SERCOM4P0/TC4WO0)
/A6: J2.7, U1.10 (PB07/AIN15/Y13)
/A7: J2.8, U1.9 (PB06/AIN14/Y12)
/A8: J2.9, U1.6 (PB05/AIN13/Y11)
/A9: J2.10, U1.5 (PB04/AIN12/Y10)
/A10: U1.16 (TC1WO1/SERCOM0P3/Y5/AIN3/AIN7/PA07)
/A11: U1.64 (PB03/AIN11/Y9/SERCOM5P1/TC6WO1)
/A12: U1.63 (PB02/AIN10/Y8/SERCOM5P0/TC6WO0)
/A13: U1.62 (PB01/AIN9/Y7/SERCOM5P3/TC7WO1), U2.9 (~DTR)
/AREF: U1.4 (Y1/AIN1/VREFA/VREFP/PA03)
/ASSOC: JP4.3, U2.15 (ASSC/DIO5); also elsewhere on the board
/CTS: U1.50 (PB23/SERCOM5P3/TC7WO1/GCLKIO1), U2.12 (~CTS)
/D0: DIGITAL1.2, U1.18 (TC0WO1/SERCOM2P1/SERCOM0P1/X1/AIN17/PA09)
/D1: DIGITAL1.1, U1.19 (GCLKIO4/TC1WO0/SERCOM2P2/SERCOM0P2/X2/A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)
/D2: DIGITAL2.2, U1.20 (GCLKIO5/TC1WO1/SERCOM2P3/SERCOM0P3/X3/A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)
/D3: DIGITAL2.1, U1.23 (PB10/SECOM4P2/TC5WO0/GCLKIO4)
/D4: J3.8, U1.24 (PB11/SERCOM4P3/TC5WO1/GCLKIO5)
/D5: J3.7, U1.25 (PB12/X12/SERC0M4P0/TC4WO0/GCLKIO6), U2.13 (ON)
/D6: J3.6, U1.26 (PB13/X13/SERCOM4P1/TC4WO1/GCLKIO7), U2.14 (VREF)
/D7: J3.5, U1.27 (PB14/X14/SERCOM4P2/TC5WO0/GCLKIO0)
/D8: J3.4, U1.28 (PB15/X15/SERCOM4P3/TC5W01/GCLKIO1)
/D9: J3.3, JP1.1, U1.31 (XIN/GCLKIO0/TC3WO0/SERCOM4P2/SERCOM2P2/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)
/D10: J3.2, U1.32 (XOUT/GCLKIO1/TC3WO1/SERCOM4P3/SERCOM2P3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)
/D11: J3.1, ONEWIRE1.2, R1.1, U1.35 (GCLKIO2/TC2WO0/SERCOM3P0/SERCOM1P0/X4/P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); also elsewhere on the board
/D12: U1.36 (GCLKIO3/TC2WO1/SERCOM3P1/SERCOM1P1/X5/P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)
/D13: U1.37 (ACCMP0/TC3WO0/SERCOM3P2/SERCOM1P2/X6/PA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)
/D15: U1.39 (PB16/SERCOM5P0/TC6WO0/GCLKIO2)
/MOSI: U1.41 (GCLKIO4/TC7WO0/SERCOM3P2/SERCOM5P2/X8/P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), U2.11 (DIO4)
/RESET: J4.10, R5.1, R6.2
/RESETN: C10.1, R5.2, R7.1, R8.2, U1.52 (~RESET~)
/RI: JP4.1, U2.20 (AD0/DIO0); also elsewhere on the board
/RI_AS: JP4.2, U1.40 (PB17/SERCOM5P1/TC6WO1/GCLKIO3); also elsewhere on the board
/RTS: U1.49 (PB22/SERCOM5P2/TC7WO0/GCLKIO0), U2.16 (~RTS)
/RXD: U1.60 (PB31/SERCOM5P1/TC0WO1), UART1.1; also elsewhere on the board
/SCK: U1.42 (GCLKIO5/TC7WO1/SERCOM3P3/SERCOM5P3/X9/P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), U2.18 (AD2/DIO2)
/SCL: 4k2.2, I2C1.1, U1.30 (ACCMP1/TC2WO1/SERCOM4P1/SERCOM2P1/PA13), U3.6 (SCL), U7.1, U8.6; also elsewhere on the board
/SDA: 4k1.2, I2C1.2, U1.29 (ACCMP0/TC2WO0/SERCOM4P0/SERCOM2P0/PA12), U3.5 (SDA), U7.3, U8.5; also elsewhere on the board
/SS_2: U1.51 (GCLKIO0/PA27)
/SWCLK: J4.4, U1.57 (GCLKIO0/SWCLK/TC1WO0/SERCOM1P2/PA30)
/SWDIO: J4.2, U1.58 (SWDIO/TC1WO1/SERCOM1P3/PA31)
/TXD: U1.59 (PB30/SERC0M5P0/TC0WO0), UART1.2; also elsewhere on the board
/USB_N: D2.1 (K), J1.2 (D-), U1.45 (TC5WO0/SERCOM5P2/SERCOM3P2/PA24)
/USB_P: D3.1 (K), J1.3 (D+), U1.46 (TC5WO1/SERCOM5P3/SERCOM3P3/PA25)
/VCC_COM: JP8.1, U1.38 (ACCMP1/TC3WO1/SERCOM3P3/SERCOM1P3/X7/PA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)
/VCC_SENS: JP7.1, U1.17 (TC0WO0/SERCOM2P0/SERCOM0P0/X0/AIN16/NMI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)
/Vddcore1: JP5.3, U1.55 (VDDCORE)
/Vddcore2: JP5.1, U1.53 (GCLKIO0/PA28)
/xBEE_MISO: JP2.1, U2.4 (DIO12)
/xBEE_RXD: JP3.1, R3.2
/xBEE_SS: JP3.3, U2.17 (AD3/DIO3)
/xBEE_TXD: JP2.3, R4.2
GND: ADC1.4, ADC2.4, C1.1, C2.1, C3.1, C4.1, C5.2, C6.1, C7.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.1 (K), D2.2 (A), D3.2 (A), D7.1 (K), DIGITAL1.4, DIGITAL2.4, I2C1.4, J1.5 (GND), J1.6 (Shield), J2.1, J3.10, J4.3, J4.5, J4.9, ONEWIRE1.4, R10.2, R11.2, SW1.2, U1.7 (GNDANA), U1.22 (GND), U1.33 (GND), U1.47 (GND), U1.54 (GND), U2.10 (GND), U3.4 (VSS), U3.7 (WP), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2, U8.4, UART1.4; also elsewhere on the board
unnamed: C5.1, L1.2, U1.8 (VDDANA)
unnamed: C6.2, U1.1 (XIN32/TC2WO0/SERCOM1P0/PA00), Y1.1
unnamed: C7.2, U1.2 (XOUT32/TC2WO1/SERCOM1P1/PA01), Y1.2
unnamed: C8.2, C9.2, JP5.2
unnamed: C12.1, D5.1 (K), JP7.3, U5.1 (VIN)
unnamed: C13.1, D6.1 (K), JP8.3, U6.1 (VIN)
unnamed: C14.1, D4.1 (K), JP6.2, U4.1 (VIN), U4.3 (CE)
unnamed: D1.2 (A), R2.1
unnamed 71: D7.2 (A), R9.1; also elsewhere on the board
unnamed: JP1.2, R2.2
unnamed: JP2.2, U1.43 (GCLKIO6/TC4WO0/SERCOM5P0/SERCOM3P0/X10/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)
unnamed: JP3.2, U1.44 (GCLKIO7/TC4WO1/SERCOM5P1/SERCOM3P1/X11/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)
unnamed: JP6.1, R9.2
unnamed: JP7.2, R10.1, U5.3 (CE)
unnamed: JP8.2, R11.1, U6.3 (CE)
unnamed: R3.1, U2.2 (DOUT)
unnamed: R4.1, U2.3 (DIN)
unnamed: R7.2, SW1.1

Notes on the sheet:
J-TAG
USB
xBEE COM
CONECTORES DEDICADOS
SENSOR SWITCH
GENERAL 3V3
COMMUNICATION SWITCH
Reset_button
Vddcore
Para L21
Para D21
CONECTORES GENERICOS
CRYPTO CHIPS

Board: 2 copper layers, 89.2 x 56.6 mm, 68 parts (37 on the bottom side), 71 nets.

Other parts of the board:
I2C: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
ON: LED; LED_1206_HandSoldering
ONEWIRE: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
Ri: Jumper_NC_Dual; SOLDER-JUMPER_2-WAY
UART: CONN_01x04; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight

Their connections:
/3V3_COM: UART.3; also elsewhere on the board
/3V3_SENS: I2C.3, ONEWIRE.3; also elsewhere on the board
/ASSOC: Ri.3; also elsewhere on the board
/D11: ONEWIRE.2; also elsewhere on the board
/RI: Ri.1; also elsewhere on the board
/RI_AS: Ri.2; also elsewhere on the board
/RXD: UART.1; also elsewhere on the board
/SCL: I2C.1; also elsewhere on the board
/SDA: I2C.2; also elsewhere on the board
/TXD: UART.2; also elsewhere on the board
GND: I2C.4, ON.1, ONEWIRE.4, UART.4; also elsewhere on the board
unnamed 71: ON.2; also elsewhere on the board

## Commit log

2018-03-22 Repo Init
    Updated license. Added files
2018-03-22 AÑADIDO DESARROLLOS EN PARALELO
2018-03-22 Test 1
2018-03-22 Añadidos puertos
    Puertos comunicaciones y sensores
2018-03-22 Reset, Vddcore
    Se ha añadido el botón de reset y el jumper para la conexión de Vddcore en función del chip a usar.
2018-03-22 Añadidos conectores genericos
    Se han añadido los conectores genéricos
2018-03-22 Actualizado anotado
2018-03-26 Modificacion de la alimentación de Vddcore
2018-03-26 Huellas asignadas.
2018-03-26 Huella Xbee incorporada
2018-03-26 Huellas actualizadas y lista de redes generada.
2018-03-26 Inicio diseño PCB
    Se ha iniciado con el diseño de la PCB
2018-03-26 Diseño pcb, punto intermedio.
2018-03-27 Pistas finalizadas.
2018-03-27 Agujeros de montaje y seriagrafía añadidos
2018-03-27 Placa finalizada.
2018-03-27 Placa final corregida.
    Corregidas algunas pistas y definido correctamente la separación del plano de pasa respecto a las pistas de alimentación y de datos
2018-03-28 Lista de materiales añadida.
2018-03-28 Serigrafia corregida
2018-03-28 Añadidos chips criptograficos.
    Se ha añadido los chips de criptografia.
2018-03-28 Chip criptografico en pcb añadido.
    Se han añadido los chips para el encriptado en el esquematico y el diseño en pcb y actualizado la lista de materiales.

Notices in the files:
PlacasPractica.kicad_pcb:
© 2018
